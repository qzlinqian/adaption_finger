Commit message: update simulator

File: adaption_finger/urdf/adaption_finger.urdf (robot description, URDF)
Before this commit: robot adaption_finger, 4 links, 3 joints
Links:
- removed link base_link
Joints:
- removed joint fake_joint
